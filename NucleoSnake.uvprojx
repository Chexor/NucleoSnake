# Keil uVision project NucleoSnake.uvprojx, settings and files
target Nucleo_One (6240000::V6.24::ARMCLANG)
  device: STM32F091RCTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: NucleoSnake +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Sources
    ./: main.c buttons.c i2c1.c oled.c snake_engine.c system_utils.c
  group Headers
    ./: buttons.h i2c1.h oled.h font6x8.h snake_engine.h system_utils.h
software components: CMSIS:CORE 6.1.1, Device:Startup 1.0.0
